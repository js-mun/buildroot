## package/testapp/Config.in
```kconfig
config BR2_PACKAGE_TESTAPP
	bool "testapp"
	depends on BR2_PACKAGE_LIBDRM
	default y
	help
	  A tiny DRM study app built on libdrm.
```
